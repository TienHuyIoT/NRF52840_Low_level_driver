# IAR project nrf_learn.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52840_xxAA NordicSemi nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10056; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA
  ICCARM.CCIncludePath2: ..\..\..\..\nRF5SDK\components; ..\..\..\..\nRF5SDK\components\boards; ..\..\..\..\nRF5SDK\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\nRF5SDK\components\libraries\atomic; ..\..\..\..\nRF5SDK\components\libraries\balloc; ..\..\..\..\nRF5SDK\components\libraries\bsp; ..\..\..\..\nRF5SDK\components\libraries\delay; ..\..\..\..\nRF5SDK\components\libraries\experimental_section_vars; ..\..\..\..\nRF5SDK\components\libraries\fifo; ..\..\..\..\nRF5SDK\components\libraries\log; ..\..\..\..\nRF5SDK\components\libraries\log\src; ..\..\..\..\nRF5SDK\components\libraries\memobj; ..\..\..\..\nRF5SDK\components\libraries\ringbuf; ..\..\..\..\nRF5SDK\components\libraries\strerror; ..\..\..\..\nRF5SDK\components\libraries\util; ..\..\..\..\nRF5SDK\components\toolchain\cmsis\include; ..\..\..\..\nRF5SDK\external\fprintf; ..\..\..\..\nRF5SDK\integration\nrfx; ..\..\..\..\nRF5SDK\integration\nrfx\legacy; ..\..\..\..\nRF5SDK\modules\nrfx; ..\..\..\..\nRF5SDK\modules\nrfx\drivers\include; ..\..\..\..\nRF5SDK\modules\nrfx\hal; ..\..\..\..\nRF5SDK\modules\nrfx\mdk; ..\..\board\config; ..\..\board; ..\..\lld\uart; ..\..\lld\tm_stdio
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: nrf_learn.hex
  ILINK.IlinkOutputFile: nrf_learn.out
  ILINK.IlinkIcfFile: C:\06_VF_RD\03_NEO_SCU\03_FW\VIN_NEO_SCU_FW\NRF52840_LEARN\Peripheral\build\iar\uart_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Application
    ../../application/: main.c
    ../../board/config/: sdk_config.h
  group Board
    ../../board/: scu_neo_board.c scu_neo_board.h
  group Low_Level_Driver
    ../../lld/uart/: app_uart.h app_uart_fifo.c uart.c uart.h
    ../../lld/tm_stdio/: tm_stdio.c tm_stdio.h
  group None
    ../../../../nRF5SDK/modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRf_Drivers
    ../../../../nRF5SDK/integration/nrfx/legacy/: nrf_drv_uart.c
    ../../../../nRF5SDK/modules/nrfx/soc/: nrfx_atomic.c
    ../../../../nRF5SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../nRF5SDK/modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c
  group nRF_Libraries
    ../../../../nRF5SDK/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../nRF5SDK/components/libraries/fifo/: app_fifo.c
    ../../../../nRF5SDK/components/libraries/atomic/: nrf_atomic.c
    ../../../../nRF5SDK/components/libraries/balloc/: nrf_balloc.c
    ../../../../nRF5SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../nRF5SDK/components/libraries/memobj/: nrf_memobj.c
    ../../../../nRF5SDK/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../nRF5SDK/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../nRF5SDK/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
